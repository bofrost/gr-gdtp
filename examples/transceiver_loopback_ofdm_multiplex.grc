<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_loopback</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>GDTP</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>GDTP</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency spacing</value></param>
<param><key>max</key><value>3</value></param>
<param><key>min</key><value>-3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>msg_interval</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>100</value></param>
<param><key>label</key><value>Message Interval [ms]</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>Noise amplitude</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>100</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1500</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>gdtp_gdtp_wrapper</key>
<param><key>id</key><value>a</value></param>
<param><key>ack_timeout</key><value>100</value></param>
<param><key>addr_source</key><value>tun0</value></param>
<param><key>addr_mode</key><value>Explicit</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_addr</key><value>1</value></param>
<param><key>reliable0</key><value>True</value></param>
<param><key>reliable10</key><value>True</value></param>
<param><key>reliable11</key><value>True</value></param>
<param><key>reliable12</key><value>True</value></param>
<param><key>reliable13</key><value>True</value></param>
<param><key>reliable14</key><value>True</value></param>
<param><key>reliable15</key><value>True</value></param>
<param><key>reliable16</key><value>True</value></param>
<param><key>reliable17</key><value>True</value></param>
<param><key>reliable18</key><value>True</value></param>
<param><key>reliable19</key><value>True</value></param>
<param><key>reliable1</key><value>False</value></param>
<param><key>reliable20</key><value>True</value></param>
<param><key>reliable21</key><value>True</value></param>
<param><key>reliable22</key><value>True</value></param>
<param><key>reliable23</key><value>True</value></param>
<param><key>reliable24</key><value>True</value></param>
<param><key>reliable25</key><value>True</value></param>
<param><key>reliable26</key><value>True</value></param>
<param><key>reliable27</key><value>True</value></param>
<param><key>reliable28</key><value>True</value></param>
<param><key>reliable29</key><value>True</value></param>
<param><key>reliable2</key><value>True</value></param>
<param><key>reliable30</key><value>True</value></param>
<param><key>reliable31</key><value>True</value></param>
<param><key>reliable3</key><value>True</value></param>
<param><key>reliable4</key><value>True</value></param>
<param><key>reliable5</key><value>True</value></param>
<param><key>reliable6</key><value>True</value></param>
<param><key>reliable7</key><value>True</value></param>
<param><key>reliable8</key><value>True</value></param>
<param><key>reliable9</key><value>True</value></param>
<param><key>num_flows</key><value>2</value></param>
<param><key>max_retry</key><value>7</value></param>
<param><key>max_seq_no</key><value>127</value></param>
<param><key>reliable</key><value>True</value></param>
<param><key>scheduler</key><value>fifo</value></param>
<param><key>src_addr</key><value>2</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("".join("x" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>msg_interval</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>msg</key><value>pmt.intern("".join("x" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>msg_interval</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Rx Packets</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset * 1.0/fft_len</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>gdtp_gdtp_wrapper</key>
<param><key>id</key><value>gdtp_gdtp_wrapper_0</value></param>
<param><key>ack_timeout</key><value>100</value></param>
<param><key>addr_source</key><value>tun0</value></param>
<param><key>addr_mode</key><value>Explicit</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_addr</key><value>2</value></param>
<param><key>reliable0</key><value>True</value></param>
<param><key>reliable10</key><value>True</value></param>
<param><key>reliable11</key><value>True</value></param>
<param><key>reliable12</key><value>True</value></param>
<param><key>reliable13</key><value>True</value></param>
<param><key>reliable14</key><value>True</value></param>
<param><key>reliable15</key><value>True</value></param>
<param><key>reliable16</key><value>True</value></param>
<param><key>reliable17</key><value>True</value></param>
<param><key>reliable18</key><value>True</value></param>
<param><key>reliable19</key><value>True</value></param>
<param><key>reliable1</key><value>False</value></param>
<param><key>reliable20</key><value>True</value></param>
<param><key>reliable21</key><value>True</value></param>
<param><key>reliable22</key><value>True</value></param>
<param><key>reliable23</key><value>True</value></param>
<param><key>reliable24</key><value>True</value></param>
<param><key>reliable25</key><value>True</value></param>
<param><key>reliable26</key><value>True</value></param>
<param><key>reliable27</key><value>True</value></param>
<param><key>reliable28</key><value>True</value></param>
<param><key>reliable29</key><value>True</value></param>
<param><key>reliable2</key><value>True</value></param>
<param><key>reliable30</key><value>True</value></param>
<param><key>reliable31</key><value>True</value></param>
<param><key>reliable3</key><value>True</value></param>
<param><key>reliable4</key><value>True</value></param>
<param><key>reliable5</key><value>True</value></param>
<param><key>reliable6</key><value>True</value></param>
<param><key>reliable7</key><value>True</value></param>
<param><key>reliable8</key><value>True</value></param>
<param><key>reliable9</key><value>True</value></param>
<param><key>num_flows</key><value>2</value></param>
<param><key>max_retry</key><value>7</value></param>
<param><key>max_seq_no</key><value>127</value></param>
<param><key>reliable</key><value>True</value></param>
<param><key>scheduler</key><value>fifo</value></param>
<param><key>src_addr</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>False</value></param>
<param><key>title</key><value>Frame Error Rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>%</value></param>
</block>
<connection><source_block_id>a</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>a</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>toMAC</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>strobe</source_key><sink_key>flowin0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_0</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>strobe</source_key><sink_key>flowin1</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>a</sink_block_id><source_key>pdus</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gdtp_gdtp_wrapper_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>toMAC</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
